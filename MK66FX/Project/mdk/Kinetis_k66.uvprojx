# Keil uVision project Kinetis_k66.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FX1M0xxx18 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Kinetis_k66
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Driver\driver;..\..\Driver\system;..\..\Driver\hardware;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group starup
    ./: startup_MK66F18.s
  group system
    ../../Driver/system/: system_MK66F18.c
  group user
    ../../User/: main.c
