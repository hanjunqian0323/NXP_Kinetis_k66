<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Kinetis_k66.ewp</path>
    </project>
    <batchBuild />
</workspace>
